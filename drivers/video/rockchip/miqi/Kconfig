## drivers/video/rockchip/miqi/Kconfig
```kconfig
config MIQI_MISC
        bool "MiQi Misc driver"
        help
          Support MiQi misc driver
```
